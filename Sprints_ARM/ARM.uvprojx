# Keil uVision project ARM.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\git\Egypt_FWD_ARM_Project_LED_Control-main\Egypt_FWD_ARM_Project_LED_Control\APP\Inc;..\..\git\Egypt_FWD_ARM_Project_LED_Control-main\Egypt_FWD_ARM_Project_LED_Control\LIB\Common\Inc;..\..\git\Egypt_FWD_ARM_Project_LED_Control-main\Egypt_FWD_ARM_Project_LED_Control\LIB\Configuration\Inc;..\..\git\Egypt_FWD_ARM_Project_LED_Control-main\Egypt_FWD_ARM_Project_LED_Control\MCAL\Inc;..\..\git\Egypt_FWD_ARM_Project_LED_Control-main\Egypt_FWD_ARM_Project_LED_Control\Services\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../../git/Egypt_FWD_ARM_Project_LED_Control-main/Egypt_FWD_ARM_Project_LED_Control/APP/Src/: main.c
  group MCAL
    ../../git/Egypt_FWD_ARM_Project_LED_Control-main/Egypt_FWD_ARM_Project_LED_Control/MCAL/Src/: gpio.c intctrl.c port_driver.c systick.c
  group LIB
    ../../git/Egypt_FWD_ARM_Project_LED_Control-main/Egypt_FWD_ARM_Project_LED_Control/LIB/Configuration/Src/: IntCtrl_cfg.c port_cfg.c
  group Services
    ../../git/Egypt_FWD_ARM_Project_LED_Control-main/Egypt_FWD_ARM_Project_LED_Control/Services/Src/: simulated_PWM.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
